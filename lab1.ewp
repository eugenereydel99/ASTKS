# IAR project lab1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR1986VE92 Milandr MDR1986VE92
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: lib\MDR32F9Qx_StdPeriph_Driver\inc; lib\MDR32F9Qx_StdPeriph_Driver\src; $PROJ_DIR$; src; lib\CMSIS\CM3\CoreSupport; lib\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc; lib\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup; lib\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lab1.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group SPL/inc
    lib/MDR32F9Qx_StdPeriph_Driver/inc/: MDR32F9Qx_port.h MDR32F9Qx_rst_clk.h
  group SPL/src
    lib/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c
  group src
    src/: button.c button.h clk.c clk.h led.c led.h type_custom.h
